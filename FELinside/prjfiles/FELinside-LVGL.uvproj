# Keil uVision project FELinside-LVGL.uvproj, settings and files
target Product (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: FELinside-LVGL
  AfterMake: fromelf --bincombined --output="$P..\output\@L.bin" !L
  AfterMake: $P..\output\postscript.bat @L.bin
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: PCB_TINY200V1,LV_CONF_INCLUDE_SIMPLE,USE_LVGL
  c include: ..\users\include;..\boot-spl\include;..\periph\include;..\include;..\..\lvgl8
  asm define: PCB_TINY200V1
  scatter file: ..\system\F1C100s.sct
  link misc: --datacompressor=on
  group BootSPL
    ../boot-spl/: startup_F1C100s.s sys-clock.c sys-copyself.c sys-dram.c sys-mmu.c sys-spiflash.c sys-uart.c
  group System
    ../system/: f1c100s-intc.c uboot_head.s uboot_entry.s mmu_a.s mmu_c.c ubox_a.s tickproc.c Retarget.c target_F1C100s.c RTX_Conf_F1C100s.c efx_main.c
  group Peripheral
    ../periph/: clk-f1c100s-pll.c fb-f1c100s.c gpio-f1c100s.c pwm-f1c100s.c reset-f1c100s.c
  group LVGL/core
    ../../lvgl8/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/draw
    ../../lvgl8/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../lvgl8/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL/extra
    ../../lvgl8/src/extra/: lv_extra.c
    ../../lvgl8/src/extra/layouts/flex/: lv_flex.c
    ../../lvgl8/src/extra/layouts/grid/: lv_grid.c
    ../../lvgl8/src/extra/libs/bmp/: lv_bmp.c
    ../../lvgl8/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../lvgl8/src/extra/libs/freetype/: lv_freetype.c
    ../../lvgl8/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../lvgl8/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../lvgl8/src/extra/libs/png/: lodepng.c lv_png.c
    ../../lvgl8/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../lvgl8/src/extra/libs/rlottie/: lv_rlottie.c
    ../../lvgl8/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../lvgl8/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../lvgl8/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../lvgl8/src/extra/others/gridnav/: lv_gridnav.c
    ../../lvgl8/src/extra/others/ime/: lv_ime_pinyin.c
    ../../lvgl8/src/extra/others/imgfont/: lv_imgfont.c
    ../../lvgl8/src/extra/others/monkey/: lv_monkey.c
    ../../lvgl8/src/extra/others/msg/: lv_msg.c
    ../../lvgl8/src/extra/others/snapshot/: lv_snapshot.c
    ../../lvgl8/src/extra/themes/basic/: lv_theme_basic.c
    ../../lvgl8/src/extra/themes/default/: lv_theme_default.c
    ../../lvgl8/src/extra/themes/mono/: lv_theme_mono.c
    ../../lvgl8/src/extra/widgets/animimg/: lv_animimg.c
    ../../lvgl8/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../lvgl8/src/extra/widgets/chart/: lv_chart.c
    ../../lvgl8/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../lvgl8/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../lvgl8/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../lvgl8/src/extra/widgets/led/: lv_led.c
    ../../lvgl8/src/extra/widgets/list/: lv_list.c
    ../../lvgl8/src/extra/widgets/menu/: lv_menu.c
    ../../lvgl8/src/extra/widgets/meter/: lv_meter.c
    ../../lvgl8/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../lvgl8/src/extra/widgets/span/: lv_span.c
    ../../lvgl8/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../lvgl8/src/extra/widgets/spinner/: lv_spinner.c
    ../../lvgl8/src/extra/widgets/tabview/: lv_tabview.c
    ../../lvgl8/src/extra/widgets/tileview/: lv_tileview.c
    ../../lvgl8/src/extra/widgets/win/: lv_win.c
  group LVGL/font
    ../../lvgl8/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/hal
    ../../lvgl8/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/misc
    ../../lvgl8/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/widgets
    ../../lvgl8/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Users Code
    ../users/: usrentry.c
  group Task-GUI
    ../users/task-gui/: LVGL_Task.c
    ../../lvgl8/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../lvgl8/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
