# Keil uVision project FELinside-emWin.uvproj, settings and files
target Product (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: FELinside-emWin
  AfterMake: fromelf --bincombined --output="$P..\output\@L.bin" !L
  AfterMake: $P..\output\postscript.bat @L.bin
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: PCB_TINY200V1
  c include: ..\users\include;..\boot-spl\include;..\periph\include;..\include;..\..\emwin\Include
  asm define: PCB_TINY200V1
  scatter file: ..\system\F1C100s.sct
  link misc: --datacompressor=on
  group BootSPL
    ../boot-spl/: startup_F1C100s.s sys-clock.c sys-copyself.c sys-dram.c sys-mmu.c sys-spiflash.c sys-uart.c
  group System
    ../system/: f1c100s-intc.c uboot_head.s uboot_entry.s mmu_a.s mmu_c.c ubox_a.s tickproc.c Retarget.c target_F1C100s.c RTX_Conf_F1C100s.c efx_main.c LCDConf.c GUI_X_RTX.c
    ../../emwin/Lib/: GUI_ARM_LA.lib
  group Peripheral
    ../periph/: clk-f1c100s-pll.c fb-f1c100s.c gpio-f1c100s.c pwm-f1c100s.c reset-f1c100s.c
  group Users Code
    ../users/: usrentry.c
  group Task-GUI
    ../users/task-gui/: GUI_Task.c
    ../users/task-gui/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
