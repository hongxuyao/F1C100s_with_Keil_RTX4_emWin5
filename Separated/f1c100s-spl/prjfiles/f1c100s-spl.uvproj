# Keil uVision project f1c100s-spl.uvproj, settings and files
target Product (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: f1c100s-spl
  AfterMake: fromelf --bincombined --output="$P..\..\output\@L.bin" !L
  AfterMake: $P..\..\output\postscript.bat @L.bin
  c flags: Optim=4 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: PCB_TINY200V1
  c include: ..\include
  asm define: PCB_TINY200V1
  scatter file: ..\source\ldscript.sct
  link misc: --datacompressor=on --no_startup
  group SPL
    ../source/: startup_spl.s main_spl.c sys-clock.c sys-dram.c sys-mmu.c sys-spiflash.c sys-uart.c crc32.c
